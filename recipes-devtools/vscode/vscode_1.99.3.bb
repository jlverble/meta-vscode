# commit hash from "about" dialog
GIT_SHA = "17baf841131aa23349f217ca7c570c76ee87b957"
# timestamp embedded in archive file name
TIMESTAMP-x64 = "1744760498"

# md5 of archive file name
SRC_URI[vscode-x64.md5sum] = "85f08dceaf424d5299de7a05b9f173d7"

require vscode.inc

LIC_FILES_CHKSUM = "file://../VSCode-linux-${VSCODE_ARCH}/LICENSES.chromium.html;md5=a28fc3669c0735c8deab7c6cdcbf9560"
